# IAR project Boot.ewp, settings and files
configuration Image Boot Manager (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; FEATURE_RESET_MACRO; ewarm
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f ..\..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\..\Tools\CC2538DB\f8wCoord.cfg
  ICCARM.CCIncludePath2: ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: Boot.bin
  ILINK.IlinkOutputFile: OTA-Boot.out
  ILINK.IlinkIcfFile: Source\cc2538.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    Source/: boot_main.c startup_ewarm.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_board.h hal_defs.h
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/CC2538/: hal_sys_ctrl.c
  group HAL/Target/Include
    ../../../../../Components/hal/target/CC2538/: hal_board_cfg.h hal_mcu.h hal_sys_ctrl.h hal_types.h iocc2538.h
  group Tools
    Source/: cc2538.icf
