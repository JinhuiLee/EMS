<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Coordinator</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Router</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EndDevice</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_SmartMeter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\uartstdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\uartstdio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\zcl_SmartMeter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\zcl_smartmeter.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\zcl_SmartMeter_data.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\common\hal_assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_ccm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_lcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_mac_cfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_sys_ctrl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_systick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\startup_ewarm.c</name>
        </file>
      </group>
      <group>
        <name>Include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_board_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_ccm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_mac_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_sys_ctrl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_systick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_types.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\iocc2538.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>MAC</name>
    <group>
      <name>High Level</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_high_level.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_pib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_pib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_spec.h</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\include\mac_api.h</name>
      </file>
    </group>
    <group>
      <name>Low Level</name>
      <group>
        <name>Common</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_assert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_autopend.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_autopend.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_backoff_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_backoff_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_low_level.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_low_level.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_radio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_radio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_rx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_rx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_rx_onoff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_rx_onoff.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_sleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\mac_tx.h</name>
        </file>
      </group>
      <group>
        <name>System</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_csp_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_csp_tx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_mcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_mem.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_radio_defs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_radio_defs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_radio_reg_defs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf05\single_chip\mac_rffrontend.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>MT</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\DebugTrace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\DebugTrace.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_AF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_AF.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_APP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_APP.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_DEBUG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_DEBUG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_NWK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_NWK.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_RPC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SYS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SYS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_TASK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_TASK.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UART.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UTIL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UTIL.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_VERSION.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_VERSION.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_ZDO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_ZDO.h</name>
    </file>
  </group>
  <group>
    <name>NWK</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AddrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_frag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_groups.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APSMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AssocList.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\BindingTable.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\BindingTable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\NLMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_bufs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\reflecttrack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\rtg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc2538\armcm3flashutil.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc2538\armcm3flashutil.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\comdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Memory.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc2538\osal_nv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Nv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_PwrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Tasks.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\ZComDef.h</name>
    </file>
  </group>
  <group>
    <name>Profile</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_ezmode.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_ezmode.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_general.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_general.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\zcl_ha.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\zcl_ha.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_ms.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zcl\zcl_ms.h</name>
    </file>
  </group>
  <group>
    <name>Security</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp_hash.h</name>
    </file>
  </group>
  <group>
    <name>Services</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\services\saddr\saddr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\services\saddr\saddr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\services\sdata\sdata.h</name>
    </file>
  </group>
  <group>
    <name>Tools</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\CC2538.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\f8wConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\f8wCoord.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\f8wEndev.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\f8wRouter.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2538DB\f8wZCL.cfg</name>
    </file>
  </group>
  <group>
    <name>ZDO</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.h</name>
    </file>
  </group>
  <group>
    <name>ZMac</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\ZMAC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_cb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_internal.h</name>
    </file>
  </group>
  <group>
    <name>ZMain</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2538DB\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2538DB\OnBoard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2538DB\ZMain.c</name>
    </file>
  </group>
</project>


