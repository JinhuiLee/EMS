# IAR project Coordinator.ewp, settings and files
configuration Coordinator (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; FEATURE_GREEN_POWER; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xHOLD_AUTO_START; ZTOOL_P1; MT_UTIL_FUNC; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_ZDO_MGMT; LCD_SUPPORTED=DEBUG; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_HVAC_CLUSTER; MT_ZDO_CB_FUNC; USB_SETUP_MAX_NUMBER_OF_INTERFACES=2; ENABLE_ASSERT
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f ..\..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\..\Tools\CC2538DB\f8wCoord.cfg; -f ..\..\..\Tools\CC2538DB\f8wZCL.cfg
  ICCARM.CCIncludePath2: ..\Source; ..\..\Source; ..\..\..\Zmain\TI2538DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf05\single_chip; ..\..\..\..\..\Components\mac\low_level\srf05; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\usblib\cc2538\source\class_cdc; ..\..\..\..\..\Components\usblib\cc2538\source\library; ..\..\..\..\..\Components\usblib\cc2538\source\library\cc2538; ..\..\..\..\..\Components\usblib\cc2538\examples\startup_files
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: Coordinator.bin
  ILINK.IlinkOutputFile: Coordinator.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Libraries\CC2538\bin\Router.a; ..\..\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Router (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
configuration EndDevice (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  ILINK.IlinkAdditionalLibs: ..\..\..\Libraries\CC2538\bin\EndDevice.a; ..\..\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  group Application
    ../Source/: OSAL_Coordinator.c uartstdio.c uartstdio.h zcl_Coordinator.c zcl_Coordinator.h zcl_Coordinator_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/CC2538/: hal_adc.c hal_aes.c hal_ccm.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.c hal_sleep.c hal_sys_ctrl.c hal_systick.c hal_uart.c startup_ewarm.c
  group HAL/Target/Include
    ../../../../../Components/hal/target/CC2538/: hal_aes.h hal_board_cfg.h hal_ccm.h hal_mac_cfg.h hal_mcu.h hal_sys_ctrl.h hal_systick.h hal_types.h iocc2538.h
  group HAL/usb/class_cdc
    ../../../../../Components/usblib/cc2538/source/class_cdc/: app_usb_descriptor.c app_usb_descriptor.h usb_cdc.c usb_cdc.h usb_cdc_hooks.c
  group HAL/usb/library
    ../../../../../Components/usblib/cc2538/source/library/: hw_usb_aliases.h usb_descriptor_defs.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_in_buffer.c usb_in_buffer.h usb_interrupt.h usb_out_buffer.c usb_out_buffer.h usb_polling_process.c usb_polling_process.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/usb/library/cc2538
    ../../../../../Components/usblib/cc2538/source/library/cc2538/: usb.c usb.h usb_firmware_library_headers.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf05/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/mcu/cc2538/: armcm3flashutil.c armcm3flashutil.h osal_nv.c
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_hvac.c zcl_hvac.h zcl_ms.c zcl_ms.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/services/sdata/: sdata.h
  group Tools
    ../../../Tools/CC2538DB/: CC2538.icf f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2538DB/: OnBoard.c OnBoard.h ZMain.c
