<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Image Boot Manager</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\Source\boot_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\startup_ewarm.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_sys_ctrl.c</name>
        </file>
      </group>
      <group>
        <name>Include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_board_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_sys_ctrl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\hal_types.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2538\iocc2538.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>Tools</name>
    <file>
      <name>$PROJ_DIR$\Source\cc2538.icf</name>
    </file>
  </group>
</project>


